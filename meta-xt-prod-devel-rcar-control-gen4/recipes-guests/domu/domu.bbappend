FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
RDEPENDS:${PN} = "backend-ready"
